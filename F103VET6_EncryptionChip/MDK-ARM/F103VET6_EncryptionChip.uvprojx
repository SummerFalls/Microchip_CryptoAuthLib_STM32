# Keil uVision project F103VET6_EncryptionChip.uvprojx, settings and files
target F103VET6_EncryptionChip (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: F103VET6_EncryptionChip +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xE,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;     ../Drivers/STM32F1xx_HAL_Driver/Inc;     ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;     ../Drivers/CMSIS/Include;     ..\cryptoauthlib\lib;     ..\cryptoauthlib\lib\basic;     ..\cryptoauthlib\lib\crypto;     ..\cryptoauthlib\lib\crypto\hashes;     ..\cryptoauthlib\lib\host;     ..\cryptoauthlib\lib\hal;     ..\cryptoauthlib\app\ip_protection;     ..\GTek;     ..\SymmetricAuth
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c adc.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_gpio.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_usart.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group GTek_Files
    ../GTek/: GTek_Delay.c GTek_Delay.h GTek_Include.h
  group EncryptionChip/User
    ../SymmetricAuth/: configuration.h host_random.c host_random.h led_patterns.c led_patterns.h provision_device.c provision_device.h
  group EncryptionChip/App
    ../cryptoauthlib/app/ip_protection/: symmetric_authentication.c symmetric_authentication.h
  group EncryptionChip/Hal
    ../cryptoauthlib/lib/hal/: atca_hal.c atca_hal.h hal_i2c_bitbang.c hal_i2c_bitbang.h hal_stm32_timer.c i2c_bitbang_stm32.c i2c_bitbang_stm32.h
  group EncryptionChip/Lib
    ../cryptoauthlib/lib/: atca_cfgs.c atca_command.c atca_device.c atca_execution.c atca_iface.c
  group EncryptionChip/Basic
    ../cryptoauthlib/lib/basic/: atca_basic.c atca_basic_aes.c atca_basic_aes_cbc.c atca_basic_aes_cmac.c atca_basic_aes_ctr.c atca_basic_aes_gcm.c atca_basic_checkmac.c atca_basic_counter.c atca_basic_derivekey.c atca_basic_ecdh.c atca_basic_gendig.c atca_basic_genkey.c atca_basic_hmac.c atca_basic_info.c atca_basic_kdf.c atca_basic_lock.c atca_basic_mac.c atca_basic_nonce.c atca_basic_privwrite.c atca_basic_random.c atca_basic_read.c atca_basic_secureboot.c atca_basic_selftest.c atca_basic_sha.c atca_basic_sign.c atca_basic_updateextra.c atca_basic_verify.c atca_basic_write.c atca_helpers.c
  group EncryptionChip/Host
    ../cryptoauthlib/lib/host/: atca_host.c atca_host.h
  group EncryptionChip/Crypto
    ../cryptoauthlib/lib/crypto/: atca_crypto_sw_sha2.c atca_crypto_sw_sha2.h
    ../cryptoauthlib/lib/crypto/hashes/: sha2_routines.c sha2_routines.h
software components: CMSIS:CORE 4.3.0
